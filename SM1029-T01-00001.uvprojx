# Keil uVision project SM1029-T01-00001.uvprojx, settings and files
target SM1029-Prj (ARM-ADS)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: SM1029-T01-00001 +hex
  AfterMake: C:\daily\Appliation\Work\MDK\app\ARM\ARMCC\bin\fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030,
  c include: .\CMISI;.\driver\inc;.\fwlib\inc;..\SM1029 -IAP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ./CMISI/: system_stm32f0xx.c startup_stm32f030.s
  group User
    ./driver/src/: main.c bord_conf.c SPI.c w25qxx.c
    ./: stm32f0xx_it.c
  group StdPeriph_Driver
    ./fwlib/src/: stm32f0xx_gpio.c stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
